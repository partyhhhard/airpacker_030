# IAR project airpacker_030.ewp, settings and files
configuration airpacker_030 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030C8 ST STM32F030C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F030x8
  ICCARM.CCIncludePath2: ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include; ../Inc; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Src\indicator; ../Src\motor; ../Src\temp_sensor; ../Src\pcconn
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: airpacker_030.bin
  ILINK.IlinkOutputFile: airpacker_030.out
  ILINK.IlinkIcfFile: stm32f030x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f030x8.s stm32f030x8_flash.icf
  group Application/lib
    ../lib/: tm_stm32_button.c tm_stm32_button.h
  group Application/User
    ../Src/: freertos.c main.cpp stm32f0xx_hal_msp.c stm32f0xx_it.c temp_sensor.cpp temp_sensor.h
  group Application/User/indicator
    ../Src/indicator/: indicator.cpp indicator.h
  group Application/User/motor
    ../Src/motor/: motor.cpp motor.h
  group Application/User/pcconn
    ../Src/pcconn/: pcconn.cpp pcconn.h
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_exti.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_5.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
